# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c misc: --diag_suppress=1 --locale=english
  c include: ..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\user\inc;..\app\LED;..\app\USART;..\app\SYSTICK;..\app\SPI_FLASH;..\app\TIM;..\app\IIC_MPU6050;..\app\SPI_LCD;..\app\ESP8266;..\DMP;..\lvgl;..\lvgl\src;..\lvgl\porting;..\guiguider;..\guiguider\guider_customer_fonts;..\guiguider\guider_fonts;..\guiguider\images;..\app\WRITE_FLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\template.sct
  group STARTUP
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_syscfg.c
  group USER
    ../user/src/: main.c stm32f4xx_it.c
  group APP
    ../app/LED/: led.c
    ../app/USART/: usart.c
    ../app/SYSTICK/: systick.c
    ../app/SPI_FLASH/: spi.c flash.c
    ../app/TIM/: tim.c
    ../app/IIC_MPU6050/: iic.c mpu6050.c
    ../app/SPI_LCD/: lcd.c
    ../app/ESP8266/: esp8266.c
    ../app/WRITE_FLASH/: write_flash.c
  group DMP
    ../DMP/: data_builder.c eMPL_outputs.c hal_outputs.c inv_mpu.c inv_mpu_dmp_motion_driver.c log_stm32.c message_layer.c ml_math_func.c mlmath.c mpl.c mpu6050_main.c results_holder.c start_manager.c storage_manager.c libmpllib.lib
  group LVGL_SRC
    ../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/src/extra/: lv_extra.c
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_PORTING
    ../lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL_GUIGUIDER
    ../guiguider/: events_init.c gui_guider.c setup_scr_screen.c
    ../guiguider/guider_fonts/: lv_font_simsun_20.c lv_font_simsun_40.c lv_font_montserratMedium_70.c
    ../guiguider/images/: _0_60x60.c weatherPattern.c
  group WEATHER_PATTERN
    ../weather_pattern/: screen_weather_pattern0.c screen_weather_pattern1.c screen_weather_pattern2.c screen_weather_pattern3.c screen_weather_pattern4.c screen_weather_pattern5.c screen_weather_pattern6.c screen_weather_pattern7.c screen_weather_pattern8.c screen_weather_pattern9.c screen_weather_pattern10.c screen_weather_pattern11.c screen_weather_pattern12.c screen_weather_pattern13.c screen_weather_pattern14.c screen_weather_pattern15.c screen_weather_pattern16.c screen_weather_pattern17.c screen_weather_pattern18.c screen_weather_pattern19.c screen_weather_pattern20.c screen_weather_pattern21.c screen_weather_pattern22.c screen_weather_pattern23.c screen_weather_pattern24.c screen_weather_pattern25.c screen_weather_pattern26.c screen_weather_pattern27.c screen_weather_pattern28.c screen_weather_pattern29.c screen_weather_pattern30.c screen_weather_pattern31.c screen_weather_pattern32.c screen_weather_pattern33.c screen_weather_pattern34.c screen_weather_pattern35.c screen_weather_pattern36.c screen_weather_pattern37.c screen_weather_pattern38.c
  group DANCE_PATTERN
    ../dance_pattern/: screen_gif_patterndance_00.c screen_gif_patterndance_01.c screen_gif_patterndance_02.c screen_gif_patterndance_03.c screen_gif_patterndance_04.c screen_gif_patterndance_05.c screen_gif_patterndance_06.c screen_gif_patterndance_07.c screen_gif_patterndance_08.c screen_gif_patterndance_09.c screen_gif_patterndance_10.c screen_gif_patterndance_11.c screen_gif_patterndance_12.c screen_gif_patterndance_13.c screen_gif_patterndance_14.c screen_gif_patterndance_15.c screen_gif_patterndance_16.c screen_gif_patterndance_17.c screen_gif_patterndance_18.c screen_gif_patterndance_19.c screen_gif_patterndance_20.c screen_gif_patterndance_21.c screen_gif_patterndance_22.c screen_gif_patterndance_23.c screen_gif_patterndance_24.c screen_gif_patterndance_25.c screen_gif_patterndance_26.c screen_gif_patterndance_27.c screen_gif_patterndance_28.c screen_gif_patterndance_29.c screen_gif_patterndance_30.c screen_gif_patterndance_31.c screen_gif_patterndance_32.c screen_gif_patterndance_33.c screen_gif_patterndance_34.c screen_gif_patterndance_35.c screen_gif_patterndance_36.c screen_gif_patterndance_37.c screen_gif_patterndance_38.c screen_gif_patterndance_39.c screen_gif_patterndance_40.c screen_gif_patterndance_41.c screen_gif_patterndance_42.c screen_gif_patterndance_43.c screen_gif_patterndance_44.c screen_gif_patterndance_45.c screen_gif_patterndance_46.c screen_gif_patterndance_47.c screen_gif_patterndance_48.c screen_gif_patterndance_49.c screen_gif_patterndance_50.c screen_gif_patterndance_51.c screen_gif_patterndance_52.c screen_gif_patterndance_53.c screen_gif_patterndance_54.c screen_gif_patterndance_55.c screen_gif_patterndance_56.c screen_gif_patterndance_57.c screen_gif_patterndance_58.c screen_gif_patterndance_59.c screen_gif_patterndance_60.c screen_gif_patterndance_61.c screen_gif_patterndance_62.c screen_gif_patterndance_63.c screen_gif_patterndance_64.c screen_gif_patterndance_65.c screen_gif_patterndance_66.c screen_gif_patterndance_67.c screen_gif_patterndance_68.c screen_gif_patterndance_69.c screen_gif_patterndance_70.c screen_gif_patterndance_71.c screen_gif_patterndance_72.c screen_gif_patterndance_73.c screen_gif_patterndance_74.c screen_gif_patterndance_75.c screen_gif_patterndance_76.c screen_gif_patterndance_77.c screen_gif_patterndance_78.c screen_gif_patterndance_79.c screen_gif_patterndance_80.c screen_gif_patterndance_81.c screen_gif_patterndance_82.c screen_gif_patterndance_83.c screen_gif_patterndance_84.c screen_gif_patterndance_85.c screen_gif_patterndance_86.c screen_gif_patterndance_87.c screen_gif_patterndance_88.c screen_gif_patterndance_89.c screen_gif_patterndance_90.c screen_gif_patterndance_91.c screen_gif_patterndance_92.c screen_gif_patterndance_93.c screen_gif_patterndance_94.c screen_gif_patterndance_95.c screen_gif_patterndance_96.c screen_gif_patterndance_97.c screen_gif_patterndance_98.c screen_gif_patterndance_99.c screen_gif_patterndance_100.c screen_gif_patterndance_101.c screen_gif_patterndance_102.c screen_gif_patterndance_103.c screen_gif_patterndance_104.c screen_gif_patterndance_105.c screen_gif_patterndance_106.c screen_gif_patterndance_107.c screen_gif_patterndance_108.c screen_gif_patterndance_109.c screen_gif_patterndance_110.c screen_gif_patterndance_111.c screen_gif_patterndance_112.c screen_gif_patterndance_113.c screen_gif_patterndance_114.c screen_gif_patterndance_115.c screen_gif_patterndance_116.c screen_gif_patterndance_117.c screen_gif_patterndance_118.c screen_gif_patterndance_119.c screen_gif_patterndance_120.c screen_gif_patterndance_121.c screen_gif_patterndance_122.c screen_gif_patterndance_123.c screen_gif_patterndance_124.c screen_gif_patterndance_125.c screen_gif_patterndance_126.c screen_gif_patterndance_127.c screen_gif_patterndance_128.c screen_gif_patterndance_129.c screen_gif_patterndance_130.c screen_gif_patterndance_131.c screen_gif_patterndance_132.c screen_gif_patterndance_133.c screen_gif_patterndance_134.c screen_gif_patterndance_135.c screen_gif_patterndance_136.c screen_gif_patterndance_137.c screen_gif_patterndance_138.c screen_gif_patterndance_139.c screen_gif_patterndance_140.c screen_gif_patterndance_141.c screen_gif_patterndance_142.c screen_gif_patterndance_143.c screen_gif_patterndance_144.c screen_gif_patterndance_145.c screen_gif_patterndance_146.c screen_gif_patterndance_147.c screen_gif_patterndance_148.c screen_gif_patterndance_149.c screen_gif_patterndance_150.c screen_gif_patterndance_151.c screen_gif_patterndance_152.c screen_gif_patterndance_153.c screen_gif_patterndance_154.c screen_gif_patterndance_155.c screen_gif_patterndance_156.c screen_gif_patterndance_157.c screen_gif_patterndance_158.c screen_gif_patterndance_159.c screen_gif_patterndance_160.c screen_gif_patterndance_161.c screen_gif_patterndance_162.c screen_gif_patterndance_163.c screen_gif_patterndance_164.c screen_gif_patterndance_165.c screen_gif_patterndance_166.c screen_gif_patterndance_167.c screen_gif_patterndance_168.c screen_gif_patterndance_169.c screen_gif_patterndance_170.c screen_gif_patterndance_171.c screen_gif_patterndance_172.c screen_gif_patterndance_173.c screen_gif_patterndance_174.c screen_gif_patterndance_175.c screen_gif_patterndance_176.c screen_gif_patterndance_177.c screen_gif_patterndance_178.c screen_gif_patterndance_179.c screen_gif_patterndance_180.c screen_gif_patterndance_181.c screen_gif_patterndance_182.c screen_gif_patterndance_183.c screen_gif_patterndance_184.c screen_gif_patterndance_185.c screen_gif_patterndance_186.c screen_gif_patterndance_187.c screen_gif_patterndance_188.c screen_gif_patterndance_189.c screen_gif_patterndance_190.c screen_gif_patterndance_191.c screen_gif_patterndance_192.c screen_gif_patterndance_193.c screen_gif_patterndance_194.c screen_gif_patterndance_195.c screen_gif_patterndance_196.c screen_gif_patterndance_197.c
  group 3D_PATTERN
    ../cat_pattern/: catPattern1.c catPattern2.c catPattern3.c catPattern4.c catPattern5.c catPattern6.c catPattern7.c catPattern8.c catPattern9.c catPattern10.c catPattern11.c catPattern12.c catPattern13.c catPattern14.c catPattern15.c catPattern16.c catPattern17.c catPattern18.c catPattern19.c catPattern20.c catPattern21.c catPattern22.c catPattern23.c catPattern24.c catPattern25.c catPattern26.c catPattern27.c catPattern28.c catPattern29.c catPattern30.c catPattern31.c catPattern32.c catPattern33.c catPattern34.c catPattern35.c catPattern36.c catPattern37.c catPattern38.c catPattern39.c catPattern40.c
  group README
    ../readme/: readme.txt
