# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\user\inc;..\app\LED;..\app\USART;..\app\SYSTICK;..\app\SPI_FLASH;..\app\TIM;..\app\IIC_MPU6050;..\app\SPI_LCD;..\app\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\template.sct
  group STARTUP
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_syscfg.c
  group USER
    ../user/src/: main.c stm32f4xx_it.c
  group APP
    ../app/LED/: led.c
    ../app/USART/: usart.c
    ../app/SYSTICK/: systick.c
    ../app/SPI_FLASH/: spi.c flash.c
    ../app/TIM/: tim.c
    ../app/IIC_MPU6050/: iic.c mpu6050.c
    ../app/SPI_LCD/: lcd.c
    ../app/ESP8266/: esp8266.c
  group README
    ../readme/: readme.txt
